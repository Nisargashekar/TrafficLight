# Keil uVision project TrafficLightVersion1.2_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: TrafficLightVersion1.2_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h timer_clock.c timer_clock.h LED_UpdateTimer.c LED_UpdateTimer.h LED_UpdateTimer_PM.c LED_UpdateISR.c LED_UpdateISR.h Red_LED.c Red_LED.h Red_LED_aliases.h Green_LED.c Green_LED.h Green_LED_aliases.h Amber_LED.c Amber_LED.h Amber_LED_aliases.h Left_Red_LED.c Left_Red_LED.h Left_Red_LED_aliases.h Left_Green_LED.c Left_Green_LED.h Left_Green_LED_aliases.h Left_Amber_LED.c Left_Amber_LED.h Left_Amber_LED_aliases.h Right_Red_LED.c Right_Red_LED.h Right_Red_LED_aliases.h Right_Green_LED.c Right_Green_LED.h Right_Green_LED_aliases.h Right_Amber_LED.c Right_Amber_LED.h Right_Amber_LED_aliases.h Front_Red_LED.c Front_Red_LED.h Front_Red_LED_aliases.h Front_Green_LED.c Front_Green_LED.h Front_Green_LED_aliases.h Front_Amber_LED.c Front_Amber_LED.h Front_Amber_LED_aliases.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cy_em_eeprom.c cy_em_eeprom.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat AfterHours.c AfterHours.h AfterHours_aliases.h timer_clock_1.c timer_clock_1.h SW_ISR1.c SW_ISR1.h timer_clock_2.c timer_clock_2.h SW_ISR2.c SW_ISR2.h ADC.c ADC.h ADC_PM.c ADC_INT.c POT.c POT.h POT_aliases.h ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h Setting_mode.c Setting_mode.h Setting_mode_aliases.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c UART_IntClock.c UART_IntClock.h EEPROM.c EEPROM.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: TrafficLightVersion1.2_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
